# Keil uVision project project.uvprojx, settings and files
target Target 1 (6140001::V6.14.1::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: Startup.s project_main.s PortF_Init.s ADC_INIT.s Read_Potentiometer.s DELAY100.s PortF_Interrupt_Init.s PortF_Interrupt_Handler.s CONVRT.s DELAY1.s OutStr.s Edge_Time_Init.s PortB_Init_Alternate.s pwm_pulse.s Periodic_Time_Init.s motor_drive_periodic_handler.s clear_screen_lcd.s Numbers_for_LCD.s SPI_Configuration.s write_brake.s write_car.s write_measure.s write_normal_operation.s write_star.s write_stars.s write_thre_adjustment.s write_threshold_for_lcd.s write_distance_obstacle.s write_distanceX.s Keypad.s
